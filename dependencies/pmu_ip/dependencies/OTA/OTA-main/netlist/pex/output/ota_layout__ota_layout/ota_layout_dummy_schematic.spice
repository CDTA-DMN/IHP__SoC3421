.subckt ota_layout VDD VSS
.ends
.end

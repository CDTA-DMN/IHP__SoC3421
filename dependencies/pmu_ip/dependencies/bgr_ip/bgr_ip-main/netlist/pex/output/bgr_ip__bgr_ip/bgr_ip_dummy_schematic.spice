.subckt bgr_ip VDD VSS
.ends
.end
